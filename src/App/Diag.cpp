#include "Diag.h"

#include "Heap.h"
#include "board.h"
#include "esp_heap_caps.h"
#include "esp_log.h"
#include "esp_timer.h"
#include "UI/Drawer.h"
#include "UI/Modal.h"
#include "UI/Popover.h"
#include "UI/Rest.h"
#include "UI/Ui.h"
#include "lvgl.h"

#include <stdio.h>
#include <string>
#include <vector>

#ifndef DIAG_STRESS
#define DIAG_STRESS 0
#endif

static const char *TAG = "diag";

namespace
{
uint32_t g_lastCopies = 0;
uint32_t g_lastTimeouts = 0;

// What gets repainted: every distinct invalidated rectangle and how often, so the 5 s line can name the busiest ones.
struct Region
{
    int16_t x1, y1, x2, y2;
    uint32_t count;
};
constexpr int kRegions = 24;
Region g_regions[kRegions];
int g_regionCount = 0;

void onInvalidate(lv_event_t *e)
{
    const lv_area_t *a = static_cast<const lv_area_t *>(lv_event_get_param(e));
    if (a == nullptr)
    {
        return;
    }
    for (int i = 0; i < g_regionCount; ++i)
    {
        Region &r = g_regions[i];
        if (r.x1 == a->x1 && r.y1 == a->y1 && r.x2 == a->x2 && r.y2 == a->y2)
        {
            r.count++;
            return;
        }
    }
    if (g_regionCount < kRegions)
    {
        g_regions[g_regionCount++] = {static_cast<int16_t>(a->x1), static_cast<int16_t>(a->y1), static_cast<int16_t>(a->x2),
                                      static_cast<int16_t>(a->y2), 1};
    }
}

void reportRegions()
{
    for (int pass = 0; pass < 4; ++pass)
    {
        int best = -1;
        for (int i = 0; i < g_regionCount; ++i)
        {
            if (g_regions[i].count && (best < 0 || g_regions[i].count > g_regions[best].count))
            {
                best = i;
            }
        }
        if (best < 0)
        {
            break;
        }
        const Region &r = g_regions[best];
        // Name what is there: the clickable object at the centre (a button or card) and any text in it.
        lv_point_t centre = {static_cast<int32_t>((r.x1 + r.x2) / 2), static_cast<int32_t>((r.y1 + r.y2) / 2)};
        lv_obj_t *obj = lv_indev_search_obj(lv_screen_active(), &centre);
        if (obj == nullptr)
        {
            obj = lv_indev_search_obj(lv_layer_top(), &centre);
        }
        char what[64] = "";
        for (lv_obj_t *o = obj; o != nullptr && what[0] == ''; o = lv_obj_get_parent(o))
        {
            for (uint32_t c = 0; c < lv_obj_get_child_count(o); ++c)
            {
                lv_obj_t *child = lv_obj_get_child(o, static_cast<int32_t>(c));
                if (lv_obj_check_type(child, &lv_label_class))
                {
                    snprintf(what, sizeof(what), "%.40s", lv_label_get_text(child));
                    break;
                }
            }
        }
        lv_area_t box = {0, 0, 0, 0};
        if (obj != nullptr)
        {
            lv_obj_get_coords(obj, &box);
        }
        ESP_LOGI(TAG, "repaint %4u x  (%d,%d)-(%d,%d)  in (%d,%d)-(%d,%d) \"%s\"", static_cast<unsigned>(r.count), r.x1, r.y1, r.x2,
                 r.y2, static_cast<int>(box.x1), static_cast<int>(box.y1), static_cast<int>(box.x2), static_cast<int>(box.y2), what);
        g_regions[best].count = 0;
    }
    g_regionCount = 0;
}

// A leak in the UI shows as a count that only grows, so count what LVGL holds: objects on every layer, timers, animations.
uint32_t countObjects(lv_obj_t *obj)
{
    uint32_t n = 1;
    const uint32_t children = lv_obj_get_child_count(obj);
    for (uint32_t i = 0; i < children; ++i)
        n += countObjects(lv_obj_get_child(obj, static_cast<int32_t>(i)));
    return n;
}

uint32_t countTimers()
{
    uint32_t n = 0;
    for (lv_timer_t *t = lv_timer_get_next(nullptr); t != nullptr; t = lv_timer_get_next(t))
        ++n;
    return n;
}

#if DIAG_STRESS
// Open and close everything over and over (build with -DDIAG_STRESS=1). If memory does not come back after a lap, the
// difference is a leak; the 5 s line then says which count kept growing.
void stress(lv_timer_t *)
{
    static uint32_t step = 0;
    ++step;
    Ui_show(static_cast<UiPage>(step % UI_PAGE_COUNT));
    switch (step % 8)
    {
    case 1:
        Drawer_open();
        break;
    case 2:
        Drawer_close();
        break;
    case 3: {
        std::vector<PopoverItem> items(10);
        for (size_t i = 0; i < items.size(); ++i)
        {
            items[i].label = "Folder " + std::to_string(i);
            items[i].detail = "D:/some/where/else";
            items[i].section = i < 3 ? "Open" : "Recent";
        }
        Popover_open(lv_obj_get_child(lv_screen_active(), 0), items, [](size_t) {});
        break;
    }
    case 4:
        Popover_close();
        break;
    case 5:
        Modal_message("Stress", "A message that opens and closes.");
        break;
    case 6:
        Modal_closeAll();
        break;
    default:
        break;
    }
}
#endif

void report(lv_timer_t *)
{
    ESP_LOGI(TAG, "page %d  rest %d  drawer %d", static_cast<int>(Ui_current()), Rest_active() ? 1 : 0, Drawer_isOpen() ? 1 : 0);
    reportRegions();
    ESP_LOGI(TAG, "lvgl objects %u (screen %u top %u sys %u)  timers %u  anims %u",
             static_cast<unsigned>(countObjects(lv_screen_active()) + countObjects(lv_layer_top()) + countObjects(lv_layer_sys())),
             static_cast<unsigned>(countObjects(lv_screen_active())), static_cast<unsigned>(countObjects(lv_layer_top())),
             static_cast<unsigned>(countObjects(lv_layer_sys())), static_cast<unsigned>(countTimers()),
             static_cast<unsigned>(lv_anim_count_running()));
    board_display_stats_t s;
    board_display_stats(&s, true);
    ESP_LOGI(TAG, "t=%us  int free %u min %u largest %u  psram free %u  copies +%u timeouts %u slow %u max %u ms",
             static_cast<unsigned>(esp_timer_get_time() / 1000000), static_cast<unsigned>(Heap_internalFree()),
             static_cast<unsigned>(Heap_internalMinFree()), static_cast<unsigned>(Heap_internalLargest()),
             static_cast<unsigned>(Heap_psramFree()), static_cast<unsigned>(s.copies - g_lastCopies), static_cast<unsigned>(s.timeouts),
             static_cast<unsigned>(s.slow_copies), static_cast<unsigned>(s.max_copy_us / 1000));
    if (s.timeouts != g_lastTimeouts)
    {
        ESP_LOGW(TAG, "t=%us  a frame copy did not complete in time", static_cast<unsigned>(esp_timer_get_time() / 1000000));
    }
    g_lastCopies = s.copies;
    g_lastTimeouts = s.timeouts;

}
} // namespace

void Diag_begin()
{
    lv_display_add_event_cb(lv_display_get_default(), onInvalidate, LV_EVENT_INVALIDATE_AREA, nullptr);
    lv_timer_create(report, 5000, nullptr);
#if DIAG_STRESS
    lv_timer_create(stress, 700, nullptr);
#endif
}

void Diag_mark(const char *what)
{
    ESP_LOGI(TAG, "mark t=%u.%03us  %s", static_cast<unsigned>(esp_timer_get_time() / 1000000),
             static_cast<unsigned>((esp_timer_get_time() / 1000) % 1000), what);
}
